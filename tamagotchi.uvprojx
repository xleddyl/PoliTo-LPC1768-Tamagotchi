# Keil uVision project tamagotchi.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tamagotchi
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: startup_LPC17xx.s main.c system_LPC17xx.c
  group Tamagotchi
    ./Tamagotchi/: tamagotchi.c tamagotchi.h
  group Timer
    ./Timer/: IRQ_timer.c lib_timer.c timer.h
  group RIT
    ./RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group GLCD_advanced
    ./GLCD_advanced/: AsciiLib.c GLCD.c HzLib.c AsciiLib.h GLCD.h HzLib.h
  group Joystick
    ./Joystick/: lib_joystick.c joystick.h
  group Button
    ./Button/: IRQ_button.c lib_button.c button.h
  group LED
    ./LED/: funct_led.c lib_led.c led.h
  group TouchPanel
    ./TouchPanel/: TouchPanel.c TouchPanel.h
  group ADC
    ./ADC/: IRQ_adc.c lib_adc.c adc.h
  group MIDI
    ./MIDI/: MIDI.c MIDI.h
software components: CMSIS:CORE 5.6.0
